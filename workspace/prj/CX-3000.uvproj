# Keil uVision project CX-3000.uvproj, settings and files
target Scope (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: CX-3000_SLA_V001 +hex
  c flags: Optim=1 uC99=1
  c define: STM32F40_41xxx, USE_CHAIN_SCOPE, USE_STDPERIPH_DRIVER, USE_FULL_ASSERT, SAMPLE_CHIP_95UM,MOTO_DOBULE_ENABLE,MOTO_Y_VERSION_V4
  c include: ..\..\HwLib\core;..\..\HwLib\driver\inc;..\..\HwLib\ETH_Driver\inc;..\..\lwip-1.4.1\src\include;..\..\lwip-1.4.1\src\include\lwip;..\..\lwip-1.4.1\src\include\ipv4;..\..\lwip-1.4.1\src\include\netif;..\..\lwip-1.4.1\port\STM32F4x7;..\..\lwip-1.4.1\port\STM32F4x7\Standalone;..\..\config;..\..\lwip_app;..\..\source;..\..\app
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3fff
  memory RVCT5: ROM 0x8008000 size 0x3ffff
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../../app/: ScopeMain.c
    ../../HwLib/core/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group Source
    ../../source/: SystemScope.c ProcessScope.c Protocol.c InterfaceScope.c SamplingPort.c StorageManagement.c
  group ETH_Driver
    ../../HwLib/ETH_Driver/src/: stm32f4x7_eth.c
  group STD_Drivers
    ../../HwLib/driver/src/: misc.c stm32f4xx_wwdg.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group Config
    ../../config/: Fpga.c Scope_It.c Scope_Eval.c Scope_Move.c BufferCircle.c NetBufferCircle.c SampleBufferCircle.c InterruptBufferCircle.c SpiFlash.c driver.c f4sys.c AD7799.c
  group LWIP_NETIF
    ../../lwip-1.4.1/port/STM32F4x7/Standalone/: ethernetif.c
    ../../lwip-1.4.1/src/netif/: etharp.c
  group LWIP_CORE
    ../../lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group LWIP_API
    ../../lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LWIP_APP
    ../../lwip_app/: netconf.c stm32f4x7_eth_bsp.c udp_echoserver.c
  group ReadMe
    ../../ReadMe/: ReadMe.txt
